# Keil uVision project Project.uvprojx, settings and files
target STM32_PSINS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: psins
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STM324xG_EVAL, STM32F4XX, USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\scr;..\Psinscore
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../scr/: stm32f4xx_it.c usart.c mpu9250.c mcu_init.c main.cpp ms5611.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group CMSIS
    ../scr/: system_stm32f4xx.c
  group MDK-ARM
    ../scr/: startup_stm32f4xx.s
  group PSINSCore
    ../Psinscore/: KFApp.cpp PSINS.cpp
software components: CMSIS:CORE 6.0.0
